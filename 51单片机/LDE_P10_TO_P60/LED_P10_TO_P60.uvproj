# Keil uVision project LED_P10_TO_P60.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: LED_P10_TO_P60 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\实验各章节程序\所用头文件
  group Source Group 1
    ./: LED_P10_TO_P60.c
